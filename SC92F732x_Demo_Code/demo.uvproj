# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8
  c include: .\include;.\user\init;.\user\main;.\user\timer;.\user\service;.\user\key;.\user\pwm;.\user\adc;.\user\uart;.\user\i2c
  group startup
    ./: STARTUP.A51
  group init
    ./user/init/: ADC_Init.c BTM.c EX_Init.c IAP_Init.c IO_Init.c LCD_Init.c PWM_Init.c Timer_Init.c Uart_Init.c
  group user
    ./user/main/: main.c SC_it.c
    ./user/timer/: timer.c
    ./user/service/: timerservice.c
    ./user/adc/: adc.c
    ./user/uart/: uart.c
    ./user/key/: key.c
  group i2c
    ./user/i2c/: i2c_master.c ep24Cx_i2c.c
